SRC_URI = "https://jaist.dl.sourceforge.net/project/half/half/${PV}/${BP}.zip"
