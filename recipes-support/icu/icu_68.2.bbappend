FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-pkgdata-increase-command-buffer-size.patch"

